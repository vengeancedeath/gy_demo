# Keil uVision project Project.uvprojx, settings and files
target STM32F072B-Discovery (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: IROM(0x08000000-0x801FFFF) IRAM(0x20000000-0x20003FFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: Project +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F072B_DISCO
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F072B-Discovery;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/CPU
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Doc
    ../: readme.txt
  group Drivers/BSP/STM32F072B-Discovery
    ../../../../Drivers/BSP/STM32F072B-Discovery/: stm32f072b_discovery.c
  group Drivers/CMSIS
    ../Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../../../../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_hal.c stm32f0xx_hal_adc.c stm32f0xx_hal_adc_ex.c stm32f0xx_hal_can.c stm32f0xx_hal_cec.c stm32f0xx_hal_comp.c stm32f0xx_hal_cortex.c stm32f0xx_hal_crc.c stm32f0xx_hal_crc_ex.c stm32f0xx_hal_dac.c stm32f0xx_hal_dac_ex.c stm32f0xx_hal_dma.c stm32f0xx_hal_flash.c stm32f0xx_hal_flash_ex.c stm32f0xx_hal_gpio.c stm32f0xx_hal_exti.c stm32f0xx_hal_i2c.c stm32f0xx_hal_i2c_ex.c stm32f0xx_hal_i2s.c stm32f0xx_hal_irda.c stm32f0xx_hal_iwdg.c stm32f0xx_hal_pcd.c stm32f0xx_hal_pcd_ex.c stm32f0xx_hal_pwr.c stm32f0xx_hal_pwr_ex.c stm32f0xx_hal_rcc.c stm32f0xx_hal_rcc_ex.c stm32f0xx_hal_rtc.c stm32f0xx_hal_rtc_ex.c stm32f0xx_hal_smartcard.c stm32f0xx_hal_smartcard_ex.c stm32f0xx_hal_smbus.c stm32f0xx_hal_spi.c stm32f0xx_hal_tim.c stm32f0xx_hal_tim_ex.c stm32f0xx_hal_tsc.c stm32f0xx_hal_uart.c stm32f0xx_hal_uart_ex.c stm32f0xx_hal_usart.c stm32f0xx_hal_wwdg.c stm32f0xx_ll_usb.c stm32f0xx_ll_usart.c stm32f0xx_ll_rcc.c
  group Example/MDK-ARM
    ./: startup_stm32f072xb.s
  group Example/User
    ../Src/: main.c stm32f0xx_hal_msp.c stm32f0xx_it.c
  group Middlewares
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
  group USB_DEVICE
    ../USB_DEVICE/App/: usb_device.c usbd_cdc_if.c usbd_desc.c
    ../USB_DEVICE/Target/: usbd_conf.c
  group Core/Src
    ../Core/Src/: usart.c logger.c open_bootloader.c
  group OpenBootLoader\App
    ../OpenBootLoader/App/: app_openbootloader.c
  group OpenBootLoader\Interface
    ../OpenBootLoader/Interface/: common_interface.c flash_interface.c iwdg_interface.c optionbytes_interface.c ram_interface.c usart_interface.c
  group OpenBootLoader\openbl
    ../OpenBootLoader/openbl/: openbl_core.c openbl_mem.c openbl_usart_cmd.c
target STM32F072B-Discovery_ASSERT_V6 (6190000::V6.19::.\ArmCompilerforEmbedded6.19)
  device: STM32F072RBTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.3.1.1
  cpu: as above
  output: Project +hex
  AfterMake: D:\keil\keil5\ARM\ArmCompilerforEmbedded6.19\bin\fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: STM32F072xB,USE_HAL_DRIVER,USE_STM32F072B_DISCO,USE_FULL_LL_DRIVER
  c include: ../Inc;../../../../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../../../../Drivers/STM32F0xx_HAL_Driver/Inc;../../../../Drivers/BSP/STM32F072B-Discovery;../../../../Drivers/BSP/Components/Common;../../../../Utilities/Log;../../../../Utilities/CPU;..\Core\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Class\CDC\Inc;..\Middlewares\ST\STM32_USB_Device_Library\Core\Inc;..\USB_DEVICE\App;..\USB_DEVICE\Target;..\..\..\..\Drivers\STM32F0xx_HAL_Driver\Inc\Legacy;..\OpenBootLoader\App;..\OpenBootLoader\Interface;..\OpenBootLoader\openbl
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
software components: CMSIS:CORE 6.1.0
